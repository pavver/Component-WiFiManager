## Kconfig
```kconfig
menu "WiFiManager"

config WIFI_AP_NAME_PREFIX
    string "default & hidden AP name prefix"
    default "esp_"
    help 
        name example esp_9AZ432

endmenu
```
